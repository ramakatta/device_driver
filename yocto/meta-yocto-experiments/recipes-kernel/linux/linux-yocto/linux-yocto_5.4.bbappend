FILESEXTRAPATHS_prepend := "${THISDIR}/patch_files:"
SRC_URI += "file://0001-block-patches.patch \
	   "
