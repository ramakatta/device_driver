IMAGE_INSTALL_append = " libsample helloworld calculator custom-cmake"

